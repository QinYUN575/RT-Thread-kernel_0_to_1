# Keil uVision project RT-Thread.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RT-Thread
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\applications;..\rtthread\bsp;..\rtthread\include;..\rtthread\libcpu\arm\cortex-m3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group docs
    ../docs/: README.md
  group applications
    ../applications/: main.c rtconfig.h
  group rtt/kernel
    ../rtthread/src/: scheduler.c thread.c
  group rtt/port
    ../rtthread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.s
software components: CMSIS:CORE 5.5.0, Device:Startup 1.2.2
